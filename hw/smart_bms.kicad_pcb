# Repository seongjun-k/smart-battery-manager

File README.md:

# 스마트 배터리 관리 디바이스

2S~6S LiPo 배터리의 셀 상태를 진단하고 보관 전압 방전, 셀 밸런싱, 용량 테스트를 자동으로 하는 장치입니다. 로봇하드웨어설계 수행평가 작품으로, 실물은 만들지 않고 회로도·PCB·펌웨어·웹 대시보드·가상 하드웨어 시뮬레이터로 설계와 동작을 검증했습니다.

## 바로 해 보기

**https://seongjun-k.github.io/smart-battery-manager/**

설치 없이 브라우저에서 가상 배터리와 웹 대시보드를 실행합니다. `sim/sim.py`를 [Pyodide](https://pyodide.org)로 브라우저 안에서 돌리고, 대시보드의 WebSocket 자리에 연결합니다(`demo/pysim.js`). 60배속으로 진행하며 진단 → 모드 선택 → 보관 방전·밸런싱·용량 테스트, 장치 탭의 결함 주입(팬 정지, 과열, 연결 불량 등)을 해 볼 수 있습니다. 주소 뒤에 `?cells=2`~`6`으로 셀 수, `?speed=`로 배속을 바꿉니다.

## 주요 기능

| 기능 | 내용 |
|---|---|
| 보관 전압 방전 | 셀당 3.80 / 3.85 / 3.90V 목표까지 최대 25W로 방전. 전력·C-rate·온도·전압·하드웨어 한도 중 최솟값으로 전류를 정함 |
| 셀 밸런싱 | BQ76907 내장 밸런싱으로 높은 셀만 방전, 동시에 최대 3셀 |
| 용량 테스트 | 가장 낮은 셀이 3.60V에 닿을 때까지 방전하며 전하량 적산 |
| 건강도 진단 | 1초 펄스 부하로 셀별 내부저항(IR)을 재고 0~100점 SOH 표시. IR 25mΩ 초과 배터리는 방전 거부 |
| 감시와 보호 | 셀 전압, 불균형, 방열판 온도, 팬 회전 감시. 셀당 3.5V 미만은 BQ76907이 하드웨어로 차단 |

장치는 OLED, 버튼 3개(NEXT·OK·STOP), 부저로 단독 동작하고, Wi-Fi AP(`SmartBMS`, 192.168.4.1)로 웹 대시보드를 제공합니다.

## 하드웨어

- MCU: ESP32-S3-WROOM-1-N8
- 배터리 모니터·보호: TI BQ76907
- 방전부: CSD18534Q5A + UCC27517 게이트 드라이버, Ohmite TEH100 5Ω 저항, Wakefield 657-15ABPE 방열판, Noctua NF-A4x20 팬
- 전원: LMR36015 벅(팩 → 5V), AP7361C LDO(5V → 3.3V)
- PCB: 100×72mm 2층, 배선은 45° 꺾임만 사용, ERC·DRC 오류 0
- 하우징: ASA 3D 프린트, 107×79×61.5mm

| 회로도 | PCB 배치 |
|---|---|
|  |  |

OLED 화면 (웹의 OLED 미러로 캡처, 펌웨어와 같은 글꼴·좌표):

## 폴더 구성

| 폴더 | 내용 |
|---|---|
| `firmware/` | ESP32-S3 펌웨어 (C++, PlatformIO + Arduino 코어) |
| `web/` | 웹 대시보드 (HTML/CSS/JS, Chart.js). 펌웨어 LittleFS와 시뮬레이터가 같은 파일을 씀 |
| `sim/` | 가상 하드웨어 시뮬레이터와 기능 테스트 (Python, aiohttp) |
| `hw/` | KiCad 10 회로도·PCB, 생성·배선 스크립트, 커스텀 풋프린트와 3D 모델 |
| `cad/` | Autodesk Inventor 하우징 모델과 생성 스크립트 |
| `demo/` | GitHub Pages용 브라우저 시뮬레이터 연결 (`.github/workflows/pages.yml`이 배포) |
| `tools/` | 보고서 그림 생성 스크립트 |
| `docs/img/` | 회로도 PDF, PCB·웹 화면 그림 |

## 실행

시뮬레이터는 ESP32-S3와 같은 JSON/WebSocket을 제공하므로 웹 대시보드를 실물 없이 써 볼 수 있습니다.

```bash
pip install aiohttp
python sim/sim.py --cells 6 --speed 60 --port 8080
# 브라우저에서 http://localhost:8080/
```

기능 테스트 12개:

```bash
python sim/test_sim.py
```

펌웨어 빌드 (PlatformIO):

```bash
cd firmware
pio run            # 펌웨어
pio run -t buildfs # 웹 파일 LittleFS 이미지
```

## 한계

실물 없이 모델로만 검증했습니다. BQ76907 결선·설정, PI 게인, 방열 성능, 부저 공진 주파수는 시제품에서 확인해야 합니다.

## KiCad design hw/smart_bms.kicad_pcb

Parts:
BZ1: BRS-03SC; BUJEON_BRS-03SC
C1: 4.7uF 50V; C_1206_3216Metric
C2, C3: 220nF 50V; C_0603_1608Metric
C4, C20, C21, C22, C23, C24, C25, C26, C32, C41, C51: 100nF; C_0603_1608Metric
C5, C30, C40, C52: 1uF; C_0603_1608Metric
C6: 20pF; C_0603_1608Metric
C7, C8, C9: 22uF 10V; C_1206_3216Metric
C10: 4.7uF; C_0805_2012Metric
C11, C50: 10uF; C_0805_2012Metric
C27, C29: 1uF 50V; C_0805_2012Metric
C28: 100pF 50V; C_0603_1608Metric
C31: 470pF 50V; C_0603_1608Metric
C33: 100pF; C_0603_1608Metric
C42: 100uF 50V; CP_Elec_10x10.5
D1: SMBJ26A; D_SMB
D2, D3: SS14; D_SMA
D4, D5: 1N4148W; D_SOD-123
D6: SS36; D_SMC
F1: 0454004.MR 4A T; Fuse_Littelfuse-NANO2-451_453
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
HS1: 657-15ABPE; Wakefield_657-15ABPE
J1: XT60PW-M; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: USB-C; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J3: BAL 7P; JST_XH_S7B-XH-A_1x07_P2.50mm_Horizontal
J4: FAN 4P; FanPinHeader_1x04_P2.54mm_Vertical
J5: BTN 4P; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J6: OLED 4P; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
L1: 15uH; L_Bourns_SRN6045TA
Q1, Q2: CSD18534Q5A; VSONP-8-1EP_5x6_P1.27mm
Q3: MMBT3904; SOT-23
R1, R33: 100k; R_0603_1608Metric
R2: 22.6k; R_0603_1608Metric
R3, R4: 5.1k; R_0603_1608Metric
R10, R11, R12, R13, R14, R15, R16: 22; R_0805_2012Metric
R17, R19, R20: 100; R_0603_1608Metric
R18: 10; R_0603_1608Metric
R21, R54, R56: 1k; R_0603_1608Metric
R30: TEH100M5R00FE; TEH100_TO-247-2_Vertical_P10.16mm
R31: 4.7; R_0603_1608Metric
R32, R50, R53, R55: 10k; R_0603_1608Metric
R51, R52: 4.7k; R_0603_1608Metric
RS1: 5m 1% 2512; R_2512_6332Metric
RT1: 103AT-2; PinHeader_1x02_P2.54mm_Vertical
SW1: EN; SW_SPST_B3U-1000P
SW2: BOOT; SW_SPST_B3U-1000P
SW3: NEXT
SW4: OK
SW5: STOP
U1: ESP32-S3-WROOM-1-N8; ESP32-S3-WROOM-1
U2: BQ76907RGR; Texas_RGR0020A_VQFN-20-1EP_3.5x3.5mm_P0.5mm_EP2.05mm
U3: LMR36015ARNXR; Texas_RNX0012C_VQFN-14-11-1EP_2x3mm_P0.5mm_EP0.25x1.825mm
U4: AP7361C-33D-13; TO-252-2
U5: UCC27517DBVR; SOT-23-5

Connections:
+3V3: C11.1, C50.1, C51.1, J6.2, R50.1, R51.1, R52.1, R53.1, U1.2 (3V3), U4.3 (OUT)
+5V: BZ1.1 (+), C10.1, C40.1, C41.1, D2.1 (K), D3.1 (K), J4.2, R56.1, U4.1 (IN), U5.1 (VDD)
/5V_BUCK: C6.1, C7.1, C8.1, C9.1, D2.2 (A), L1.2, R1.1
/ALERT: R53.2, U1.21 (IO13), U2.14 (ALERT)
/BTN_NEXT: J5.1, SW3.1, U1.4 (IO4)
/BTN_OK: J5.2, SW4.1, U1.5 (IO5)
/BTN_STOP: J5.3, SW5.1, U1.6 (IO6)
/BUZZER: R54.1, U1.7 (IO7)
/DSG: R21.1, U2.9 (DSG)
/FAN_PWM: J4.4, U1.19 (IO11)
/FAN_TACH: J4.3, U1.20 (IO12)
/LOAD_PWM: U1.18 (IO10), U5.3 (IN+)
/SCL: J6.3, R52.2, U1.17 (IO9), U2.12 (SCL)
/SDA: J6.4, R51.2, U1.12 (IO8), U2.13 (SDA)
/SHUNT_N: Q1.1 (S), R20.1, RS1.1
/SRN: C32.2, C33.2, R20.2, U2.7 (SRN)
/SRP: C32.1, C33.1, R19.2, U2.6 (SRP)
/TS: C31.1, RT1.1, U2.8 (TS)
/USB_DN: J2.A7 (D-), J2.B7 (D-), U1.13 (USB_D-)
/USB_DP: J2.A6 (D+), J2.B6 (D+), U1.14 (USB_D+)
/VPACK: C1.1, C2.1, C3.1, C42.1, D1.1 (K), D4.2 (A), D5.2 (A), D6.1 (K), F1.2, R30.1, U3.2 (VIN), U3.9 (EN), U3.10 (VIN)
GND: C1.2, C2.2, C3.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C20.2, C27.2, C28.2, C29.2, C30.2, C31.2, C40.2, C41.2, C42.2, C50.2, C51.2, C52.2, D1.2 (A), J1.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), J4.1, J5.4, J6.1, Q3.2 (E), R2.2, R3.2, R4.2, R19.1, R33.2, R55.2, RS1.2, RT1.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.11 (VSS), U2.21 (EP), U3.1 (PGND), U3.6 (AGND), U3.11 (PGND), U4.2 (GND), U5.2 (GND), U5.4 (IN-)
unnamed: BZ1.2 (-), Q3.3 (C), R56.2
unnamed: D4.1 (K), R17.1
unnamed: D5.1 (K), R18.1
unnamed: D6.2 (A), Q2.3 (D), R30.2
unnamed: F1.1, J1.2
unnamed: J2.A5 (CC1), R3.1
unnamed: J2.B5 (CC2), R4.1
unnamed: J3.1, R10.1
unnamed: J3.2, R11.1
unnamed: J3.3, R12.1
unnamed: J3.4, R13.1
unnamed: J3.5, R14.1
unnamed: J3.6, R15.1
unnamed: J3.7, R16.1
unnamed: Q1.3 (D), Q2.1 (S), R32.2, R33.1
unnamed: Q1.2 (G), R21.2
unnamed: Q2.2 (G), R31.2, R32.1
unnamed: Q3.1 (B), R54.2, R55.1
unnamed: C52.1, R50.2, SW1.1, U1.3 (EN)
unnamed: SW2.1, U1.27 (IO0)
unnamed: C27.1, C28.1, R17.2, U2.17 (BAT)
unnamed: C30.1, U2.15 (REGOUT)
unnamed: C29.1, R18.2, U2.16 (REGSRC)
unnamed: C20.1, C21.2, R10.2, U2.5 (VC0)
unnamed: C21.1, C22.2, R11.2, U2.4 (VC1)
unnamed: C22.1, C23.2, R12.2, U2.3 (VC2)
unnamed: C23.1, C24.2, R13.2, U2.1 (VC4), U2.2 (VC3)
unnamed: C24.1, C25.2, R14.2, U2.20 (VC5)
unnamed: C25.1, C26.2, R15.2, U2.19 (VC6)
unnamed: C26.1, R16.2, U2.18 (VC7)
unnamed: C4.1, U3.4 (BOOT)
unnamed: C6.2, R1.2, R2.1, U3.7 (FB)
unnamed: C4.2, L1.1, U3.3 (NC), U3.12 (SW)
unnamed: C5.1, U3.5 (VCC)
unnamed: R31.1, U5.5 (OUT)
VBUS: D3.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)

Notes on the sheet:
1. 전원 (입력 보호 · 5V 벅 · USB · 3.3V LDO)
2. BQ76907 셀 측정 · 보호
R19 GND는 RS1의 GND 끝에서 켈빈 선으로
3. 방전부
4. MCU · UI
덮개 패널 버튼 (PCB 미실장)
밸런스 7핀 결선 (TRM SLUUCJ0 표 5-8, 6셀 모드) 핀1 VC0, 핀2 VC1, 핀3 VC2, 핀4 VC3·VC4, 핀5 VC5, 핀6 VC6, 핀7 VC7 VC4는 쓰지 않는 입력이라 VC3에 단락한다. 변환 케이블 (배터리 B0~Bn → 장치 핀) 6S: B0~B6 → 1~7 5S: B0→1, B1→2, B2→3, B3→4, B4→5·6, B5→7 4S: B0→1, B1→2·3, B2→4, B3→5·6, B4→7 3S: B0→1, B1→2·3·4, B2→5·6, B3→7 2S: B0→1, B1→2~6, B2→7 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
전원: XT60 → 퓨즈 → VPACK. LMR36015(400kHz) 5V와 USB VBUS를 쇼트키로 OR하고 LDO로 3.3V. SMBJ26A 클램프 42.1V는 BAT·VC 단시간 정격 45V 안(DS 6.1). 평상시 최대 6S 25.2V.
BQ76907: 기본 OTP에서 REGOUT 3.3V가 켜져 있어 C30만 둔다. CHG는 쓰지 않는다. R19는 RS1의 GND 끝에서 켈빈 선으로 잇는다.
방전: R30 → Q2(PWM) → Q1(BQ76907 DSG) → RS1 → 배터리 -. R30 TEH100은 HS1(657-15ABPE) 세로판에 M3로 고정하고, RT1(103AT-2)은 R30 옆 방열판에 붙인다.
UI: OLED와 패널 버튼은 덮개에 달고 J6·J5 케이블로 잇는다. 팬 PWM은 3.3V로 직접 구동한다(Noctua: 3.3V를 high로 인식). 딥슬립 중 PWM LOW = 0rpm.

Board: 2 copper layers, 100.0 x 72.0 mm, 90 parts (2 on the bottom side), 58 nets.

## Code that names these connections

File firmware/src/config.h:

#pragma once
// 핀, Wi-Fi, 주기, 제어 상수를 한 곳에 둔다.
// 제어 상수는 sim/sim.py와 같은 값을 유지한다. 한쪽을 바꾸면 다른 쪽도 고친다.
#include <stdint.h>

// ---- 핀 배정 (docs/결과보고서_초안.md 3-1 표) ----
constexpr int PIN_SDA = 8;           // BQ76907, OLED 공유
constexpr int PIN_SCL = 9;
constexpr int PIN_BQ_ALERT = 13;     // 현재 폴링 방식이라 입력으로만 둔다
constexpr int PIN_BTN_NEXT = 4;      // 내부 풀업, 누르면 LOW
constexpr int PIN_BTN_OK = 5;
constexpr int PIN_BTN_STOP = 6;
constexpr int PIN_BUZZER = 7;        // 패시브 부저 + NPN
constexpr int PIN_LOAD = 10;         // 방전 MOSFET 게이트
constexpr int PIN_FAN_PWM = 11;
constexpr int PIN_FAN_TACH = 12;

// ---- Wi-Fi (AP 모드만 사용) ----
#define WIFI_SSID "SmartBMS"
#define WIFI_PASS "smartbms1234"     // WPA2는 8자 이상이어야 한다
// 주소는 ESP32 기본값 192.168.4.1

// ---- 주기 ----
constexpr uint32_t CTRL_PERIOD_MS = 100;   // sim DT와 같다
constexpr uint32_t STATUS_EVERY = 2;       // 제어 주기 2번마다 상태 전송 = 5Hz

// ---- PWM (Arduino 코어 3.x LEDC) ----
// 해상도는 APB 80MHz에서 주파수별 최대치(20kHz 11비트, 25kHz 11비트) 안쪽으로 잡는다
constexpr uint32_t LOAD_PWM_HZ = 20000;
constexpr uint8_t LOAD_PWM_BITS = 10;
constexpr uint32_t FAN_PWM_HZ = 25000;     // 4핀 PWM 팬 표준
constexpr uint8_t FAN_PWM_BITS = 10;
constexpr uint32_t BUZZER_BASE_HZ = 2000;
constexpr uint8_t BUZZER_BITS = 8;

// ---- 팬 ----
constexpr int FAN_TACH_PULSES_PER_REV = 2;
constexpr uint32_t FAN_RPM_WINDOW_MS = 500;
constexpr double FAN_GRACE_S = 2.0;        // 팬을 켠 뒤 이 시간이 지나야 정지 판정 (기동 지연)

// ---- 측정 ----
constexpr int MAX_CELLS = 6;
constexpr float SHUNT_MOHM = 5.0f;         // 보고서 3-1: 5mΩ 션트. BQ 전류값(1mΩ 기준 mA)을 실제 전류로 환산한다
constexpr float CELL_PRESENT_V = 2.5f;     // sim: cell_count = (셀 > 2.5V)인 개수
constexpr float V_FILT_ALPHA = 0.1f;       // 약 1초 이동평균 (100ms 주기)

// ---- 제어 상수 (sim.py와 동일) ----
constexpr double DT = 0.1;
constexpr float P_TARGET = 25.0f;
constexpr float I_HW = 5.0f;
constexpr float C_RATE = 1.0f;
constexpr float KP = 0.02f, KI = 0.1f;     // 임의값, 실측으로 재조정
constexpr float MAX_STEP = 0.05f;          // 제어 주기당 듀티 변화 한도 (소프트 스타트 겸용)
constexpr float TAPER_V = 0.10f;
constexpr float TAPER_MIN = 0.05f;
constexpr double REST_S = 30.0;
constexpr float REST_MARGIN = 0.02f;
constexpr float V_CUTOFF = 3.5f;
constexpr float IMBALANCE_V = 0.05f;
constexpr float IMBALANCE_HYST_V = 0.010f; // 경고가 켜진 뒤엔 이만큼 더 내려가야 꺼진다
constexpr float FAN_ON_T = 40.0f;
constexpr float DIAG_DUTY = 0.5f;
constexpr double DONE_HOLD_S = 5.0;
constexpr int BAL_MAX_CELLS = 3;           // 칩 발열 때문에 동시에 밸런싱하는 셀 수 상한
constexpr float BAL_AUTO_V = 0.015f;       // 보관 방전이 끝났을 때 셀 편차가 이보다 크면 밸런싱으로 자동 전환
constexpr float BAL_ON_V = 0.005f;
constexpr float BAL_DONE_V = 0.010f;
constexpr float CAP_END_V = 3.60f;
constexpr float CHARGE_V = 3.70f;          // 실행 중이 아닐 때 최저 셀이 이보다 낮으면 CHARGE_NEEDED
constexpr float CHARGE_HYST_V = 0.020f;    // 켜진 뒤엔 이만큼 더 올라야 꺼진다
constexpr float IR_LIMIT_MOHM = 25.0f;     // 셀 IR이 이보다 크면 HIGH_IR, 방전 거부
constexpr float CAPACITY_AH = 2.2f;        // 웹에서 값을 안 주면 쓰는 기본 용량
constexpr float R_LOAD = 5.0f;             // TO-247 후막 저항 TEH100 5Ω 1개
constexpr float TEMP_SINK_DERATE = 80.0f, TEMP_SINK_TRIP = 95.0f;
constexpr float TARGET_PRESETS[3] = {3.80f, 3.85f, 3.90f};

// ---- 완료 후 딥슬립 ----
// DONE 진입 후 이 시간이 지나면 AP·OLED·팬·BQ를 끄고 OK 버튼(GPIO5, LOW)으로 깨운다
constexpr double SLEEP_AFTER_S = 600.0;
